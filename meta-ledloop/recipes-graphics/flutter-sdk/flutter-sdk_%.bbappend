do_compile:append() {
    flutter config --enable-web
}
